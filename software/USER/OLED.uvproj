# Keil uVision project OLED.uvproj, settings and files
target OLED (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\OLED;..\FWLIB\inc;D:\SoftWare\keil\ARM\PACK\ARM\CMSIS\5.4.0\CMSIS\Include;D:\SoftWare\keil\ARM\PACK\ARM\CMSIS\4.5.0\CMSIS\Include;..\HARDWARE\LD3320;..\HARDWARE;..\FATFS\src;..\FATFS\exfuns;..\HARDWARE\MMC_SD;..\HARDWARE\SPI;..\HARDWARE\I2S;..\HARDWARE\TIMER;..\HARDWARE\DataScope_DP;..\HARDWARE\ZLG_GUI;..\HARDWARE\FFT_LIB;..\HARDWARE\ESP8266_WIFI;..\HMAC\inc;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/LD3320/: ld3320.c
    ../HARDWARE/MMC_SD/: mmc_sd.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group ESP8266_WIFI
    ../HARDWARE/ESP8266_WIFI/: wifi.c mqtt.c
  group FFT_LIB
    ../HARDWARE/FFT_LIB/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s FFT.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group PC_Graphic
    ../HARDWARE/DataScope_DP/: DataScope_DP.C
  group ZLG_GUI
    ../HARDWARE/ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C lcmdrv.c loadbit.c menu.c spline.c windows.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_tim.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
